# Keil uVision project LUNAR.uvprojx, settings and files
target LUNAR (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LUNAR
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,STM32F10X_MD
  c include: .;Core\Inc;Drivers\STM32F1xx_HAL_Driver\Inc;Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;Drivers\CMSIS\Device\ST\STM32F1xx\Include;Drivers\CMSIS\Include;My_Driver;.cmsis\include;MDK-ARM\RTE\_LUNAR;RTE\_LUNAR
  asm define: USE_HAL_DRIVER,STM32F103xB,STM32F10X_MD
  library: MicroLIB
  memory RVCT1: ROM 0x8000000 size 0x10000
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT6: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    Core/Src/: main.c gpio.c adc.c dma.c rtc.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c MultiTimer.c
  group Drivers/STM32F1xx_HAL_Driver
    Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    Core/Src/: system_stm32f1xx.c
  group My_Driver
    My_Driver/: alarm.c flash.c key.c mytime.c ntc.c pid.c protocol.c led.c register_interface.c hardware_register.c beep.c shortcut.c bt401.c
